## zephyr/sifli/boards/lilygo/t_display_sf32/board.yml
```yaml
board:
  name: t_display_sf32
  full_name: LilyGo T-Display SF32
  vendor: lilygo
  socs:
    - name: sf32lb525uc6
```
